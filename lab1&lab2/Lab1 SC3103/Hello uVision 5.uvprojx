# Keil uVision project Hello uVision 5.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Hello uVision 5 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER, FPU_PRESENT=1, _TARGET_FPU_VFP, ARM_MATH_CM4, _CC_ARM
  c include: ..\Downloads\CORE;..\Downloads\STM32F4xx_Driver\inc;..\Downloads\FreeRTOS_CORE\include;..\Downloads\FreeRTOS_PORTABLE;..\Downloads\Hardware;..\Downloads\SYSTEM\sys;..\Downloads\SYSTEM\delay
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../Downloads/CORE/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s
  group SYSTEM
    ../Downloads/SYSTEM/sys/: sys.c system.c
    ../Downloads/SYSTEM/delay/: delay.c
  group FreeRTOS_CORE
    ../Downloads/FreeRTOS_CORE/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../Downloads/FreeRTOS_PORTABLE/: heap_4.c port.c
  group Hardware
    ../Downloads/Hardware/: led.c oled.c show.c
    ./: buzzer.h buzzer.c
  group STM32F4xx_Driver
    ../Downloads/STM32F4xx_Driver/src/: stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c misc.c stm32f4xx_adc.c
  group Main
    ./: main.c
